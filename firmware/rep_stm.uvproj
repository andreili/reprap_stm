# Keil uVision project rep_stm.uvproj, settings and files
target RepRap from STM32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rep_stm +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD
  c include: .\core
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ./core/: system_stm32f10x.c core_cm3.c stm32f10x.h system_stm32f10x.h startup_stm32f10x_hd.s
  group programm
    ./programm/: main.c
